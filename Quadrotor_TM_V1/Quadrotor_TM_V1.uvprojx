# Keil uVision project Quadrotor_TM_V1.uvprojx, settings and files
target Quadrotor_TM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Quadrotor_TM_V1i
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_IS_TM4C123_RB1 PART_TM4C123GH6PM
  c include: .\TiDriver\inc;.\TiDriver\inc\driver_inc;.\TiDriver\inc\driver_hw;.\TiDriver\inc\driver_usb;.\TiDriver\inc\driver_usb\device;.\Application\Core;.\Application\Service;.\Application\Mission;.\Application\Vision;.\Driver\BSP;.\Driver\Peripheral;.\Driver\Sensor;.\Driver\ExtDevice;.\Algorithm\Common;.\Algorithm\Estimation;.\Algorithm\Control
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Application_Core
    ./Application/Core/: main.c sysconfig.h Scheduler.c Scheduler.h
  group Application_Service
    ./Application/Service/: Parameter.c Parameter.h DT.c DT.h RC.c RC.h LED.c LED.h FcUsbCdc.c FcUsbCdc.h
  group Application_Mission
    ./Application/Mission/: FlyCtrl.c FlyCtrl.h ProgramCtrl_User.c ProgramCtrl_User.h User_control.c User_control.h
  group Application_Vision
    ./Application/Vision/: OF_DecoFusion.c OF_DecoFusion.h OPMV_CBTracking_Ctrl.c OPMV_CBTracking_Ctrl.h OPMV_LineTracking_Ctrl.c OPMV_LineTracking_Ctrl.h OPMV_Ctrl.c OPMV_Ctrl.h
  group TiDriver
    ./TiDriver/src/: startup_TM4C123.s system_TM4C123.c usb_serial_structs.c
    ./TiDriver/inc/: usb_serial_structs.h
    ./TiDriver/: driverlib.lib usblib.lib
  group Driver_BSP
    ./Driver/BSP/: Drv_Bsp.c Drv_Bsp.h Drv_Adc.c Drv_Adc.h Drv_Led.c Drv_Led.h
  group Driver_Peripheral
    ./Driver/Peripheral/: Drv_Paramter.c Drv_Paramter.h Drv_RcIn.c Drv_RcIn.h Drv_PwmOut.c Drv_PwmOut.h Drv_Spi.c Drv_Spi.h Drv_Uart.c Drv_Uart.h
  group Driver_Sensor
    ./Driver/Sensor/: Drv_icm20602.c Drv_icm20602.h Drv_ak8975.c Drv_ak8975.h Drv_spl06.c Drv_spl06.h Drv_heating.c Drv_heating.h
  group Driver_ExtDevice
    ./Driver/ExtDevice/: Drv_gps.c Drv_gps.h OF.c OF.h UWB.c UWB.h Drv_OpenMV.c Drv_OpenMV.h Drv_UP_Flow.c Drv_UP_Flow.h Drv_laser.c Drv_laser.h
  group Algorithm_Common
    ./Algorithm/Common/: FcData.c FcData.h config.h Filter.c Filter.h Math.c Math.h Pid.c Pid.h
  group Algorithm_Estimation
    ./Algorithm/Estimation/: Imu.c Imu.h Sensor_Basic.c Sensor_Basic.h MotionCal.c MotionCal.h Navigate.c Navigate.h MagProcess.c MagProcess.h FlightDataCal.c FlightDataCal.h
  group Algorithm_Control
    ./Algorithm/Control/: AltCtrl.c AltCtrl.h AttCtrl.c AttCtrl.h FlightCtrl.c FlightCtrl.h LocCtrl.c LocCtrl.h MotorCtrl.c MotorCtrl.h Power.c Power.h
